* SPICE netlist generated by Yosys 0.28+1 (git sha1 a9c792dce, clang 10.0.0-4ubuntu1 -fPIC -Os)

X0 sel0.12 1 __NOT_
X1 sel1.12 2 __NOT_
X2 sel0.11 3 __NOT_
X3 sel1.11 4 __NOT_
X4 sel0.10 5 __NOT_
X5 sel1.10 6 __NOT_
X6 sel0.9 7 __NOT_
X7 sel1.9 8 __NOT_
X8 sel0.8 9 __NOT_
X9 sel1.8 10 __NOT_
X10 sel0.7 11 __NOT_
X11 sel1.7 12 __NOT_
X12 sel0.6 13 __NOT_
X13 sel1.6 14 __NOT_
X14 sel0.5 15 __NOT_
X15 sel1.5 16 __NOT_
X16 sel0.4 17 __NOT_
X17 sel1.4 18 __NOT_
X18 sel0.3 19 __NOT_
X19 sel1.3 20 __NOT_
X20 sel0.2 21 __NOT_
X21 sel1.2 22 __NOT_
X22 sel0.1 23 __NOT_
X23 sel1.1 24 __NOT_
X24 sel0.0 25 __NOT_
X25 sel1.0 26 __NOT_
X26 sel0.13 27 __NOT_
X27 sel1.13 28 __NOT_
X28 sel0.14 29 __NOT_
X29 sel1.14 30 __NOT_
X30 sel0.15 31 __NOT_
X31 sel1.15 32 __NOT_
X32 sel0.11 sel1.11 33 __NAND_
X33 3 4 34 __NAND_
X34 33 34 35 __NAND_
X35 35 36 __NOT_
X36 sel0.10 sel1.10 37 __NAND_
X37 5 6 38 __NAND_
X38 37 38 39 __NAND_
X39 39 40 __NOT_
X40 sel0.9 sel1.9 41 __NAND_
X41 7 8 42 __NAND_
X42 41 42 43 __NAND_
X43 43 44 __NOT_
X44 sel0.8 sel1.8 45 __NAND_
X45 9 10 46 __NAND_
X46 45 46 47 __NAND_
X47 47 48 __NOT_
X48 sel0.7 sel1.7 49 __NAND_
X49 11 12 50 __NAND_
X50 sel0.6 sel1.6 51 __NAND_
X51 13 14 52 __NAND_
X52 51 52 53 __NAND_
X53 53 54 __NOT_
X54 sel0.5 sel1.5 55 __NAND_
X55 sel0.4 sel1.4 56 __NAND_
X56 17 18 57 __NAND_
X57 56 57 58 __NAND_
X58 58 59 __NOT_
X59 sel0.3 sel1.3 60 __NAND_
X60 sel0.2 sel1.2 61 __NAND_
X61 21 22 62 __NAND_
X62 61 62 63 __NAND_
X63 63 64 __NOT_
X64 sel0.1 sel1.1 65 __NAND_
X65 sel0.0 sel1.0 66 __NAND_
X66 66 67 __NOT_
X67 23 24 68 __NAND_
X68 65 68 69 __NAND_
X69 69 70 __NOT_
X70 67 70 71 __NAND_
X71 65 71 72 __NAND_
X72 72 73 __NOT_
X73 64 72 74 __NAND_
X74 61 74 75 __NAND_
X75 75 76 __NOT_
X76 19 20 77 __NAND_
X77 60 77 78 __NAND_
X78 78 79 __NOT_
X79 75 79 80 __NAND_
X80 60 80 81 __NAND_
X81 81 82 __NOT_
X82 59 81 83 __NAND_
X83 56 83 84 __NAND_
X84 84 85 __NOT_
X85 15 16 86 __NAND_
X86 55 86 87 __NAND_
X87 87 88 __NOT_
X88 84 88 89 __NAND_
X89 55 89 90 __NAND_
X90 90 91 __NOT_
X91 54 90 92 __NAND_
X92 51 92 93 __NAND_
X93 93 94 __NOT_
X94 50 93 95 __NAND_
X95 49 94 96 __NAND_
X96 50 96 97 __NAND_
X97 49 95 98 __NAND_
X98 48 98 99 __NAND_
X99 45 99 100 __NAND_
X100 100 101 __NOT_
X101 44 100 102 __NAND_
X102 41 102 103 __NAND_
X103 103 104 __NOT_
X104 40 103 105 __NAND_
X105 37 105 106 __NAND_
X106 106 107 __NOT_
X107 36 106 108 __NAND_
X108 33 108 109 __NAND_
X109 109 110 __NOT_
X110 1 2 111 __NAND_
X111 sel0.12 sel1.12 112 __NAND_
X112 111 112 113 __NAND_
X113 113 114 __NOT_
X114 109 114 115 __NAND_
X115 110 113 116 __NAND_
X116 115 116 117 __NAND_
X117 117 118 __NOT_
X118 112 115 119 __NAND_
X119 119 120 __NOT_
X120 27 28 121 __NAND_
X121 sel0.13 sel1.13 122 __NAND_
X122 121 122 123 __NAND_
X123 123 124 __NOT_
X124 119 124 125 __NAND_
X125 120 123 126 __NAND_
X126 125 126 127 __NAND_
X127 127 128 __NOT_
X128 122 125 129 __NAND_
X129 129 130 __NOT_
X130 29 30 131 __NAND_
X131 sel0.14 sel1.14 132 __NAND_
X132 131 132 133 __NAND_
X133 133 134 __NOT_
X134 129 134 135 __NAND_
X135 130 133 136 __NAND_
X136 135 136 137 __NAND_
X137 137 138 __NOT_
X138 132 135 139 __NAND_
X139 139 140 __NOT_
X140 31 32 141 __NAND_
X141 sel0.15 sel1.15 142 __NAND_
X142 sel0.15 32 143 __NAND_
X143 31 sel1.15 144 __NAND_
X144 143 144 145 __NAND_
X145 141 142 146 __NAND_
X146 140 145 147 __NAND_
X147 139 146 148 __NAND_
X148 147 148 149 __NAND_
X149 25 26 150 __NAND_
X150 66 150 151 __NAND_
X151 151 152 __NOT_
X152 66 69 153 __NAND_
X153 71 153 154 __NAND_
X154 154 155 __NOT_
X155 63 73 156 __NAND_
X156 74 156 157 __NAND_
X157 157 158 __NOT_
X158 76 78 159 __NAND_
X159 80 159 160 __NAND_
X160 160 161 __NOT_
X161 58 82 162 __NAND_
X162 83 162 163 __NAND_
X163 163 164 __NOT_
X164 85 87 165 __NAND_
X165 89 165 166 __NAND_
X166 166 167 __NOT_
X167 53 91 168 __NAND_
X168 92 168 169 __NAND_
X169 169 170 __NOT_
X170 49 50 171 __NAND_
X171 171 172 __NOT_
X172 93 171 173 __NAND_
X173 94 172 174 __NAND_
X174 173 174 175 __NAND_
X175 47 97 176 __NAND_
X176 99 176 177 __NAND_
X177 177 178 __NOT_
X178 43 101 179 __NAND_
X179 102 179 180 __NAND_
X180 180 181 __NOT_
X181 39 104 182 __NAND_
X182 105 182 183 __NAND_
X183 183 184 __NOT_
X184 35 107 185 __NAND_
X185 108 185 186 __NAND_
X186 186 187 __NOT_
V0 sel0.12 188 DC 0
V1 sel1.12 189 DC 0
V2 sel0.11 190 DC 0
V3 sel1.11 191 DC 0
V4 sel0.10 192 DC 0
V5 sel1.10 193 DC 0
V6 sel0.9 194 DC 0
V7 sel1.9 195 DC 0
V8 sel0.8 196 DC 0
V9 sel1.8 197 DC 0
V10 sel0.7 198 DC 0
V11 sel1.7 199 DC 0
V12 sel0.6 200 DC 0
V13 sel1.6 201 DC 0
V14 sel0.5 202 DC 0
V15 sel1.5 203 DC 0
V16 sel0.4 204 DC 0
V17 sel1.4 205 DC 0
V18 sel0.3 206 DC 0
V19 sel1.3 207 DC 0
V20 sel0.2 208 DC 0
V21 sel1.2 209 DC 0
V22 sel0.1 210 DC 0
V23 sel1.1 211 DC 0
V24 sel0.0 212 DC 0
V25 sel1.0 213 DC 0
V26 118 out.12 DC 0
V27 sel0.13 214 DC 0
V28 sel1.13 215 DC 0
V29 128 out.13 DC 0
V30 sel0.14 216 DC 0
V31 sel1.14 217 DC 0
V32 138 out.14 DC 0
V33 sel0.15 218 DC 0
V34 sel1.15 219 DC 0
V35 149 out.15 DC 0
V36 152 out.0 DC 0
V37 155 out.1 DC 0
V38 158 out.2 DC 0
V39 161 out.3 DC 0
V40 164 out.4 DC 0
V41 167 out.5 DC 0
V42 170 out.6 DC 0
V43 175 out.7 DC 0
V44 178 out.8 DC 0
V45 181 out.9 DC 0
V46 184 out.10 DC 0
V47 187 out.11 DC 0

************************
* end of SPICE netlist *
************************
