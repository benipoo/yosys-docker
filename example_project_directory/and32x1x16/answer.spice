* SPICE netlist generated by Yosys 0.28+1 (git sha1 a9c792dce, clang 10.0.0-4ubuntu1 -fPIC -Os)

X0 and_input1.0 and_input0.0 1 __NAND_
X1 1 2 __NOT_
V0 and_input1.0 3 DC 0
V1 and_input0.0 4 DC 0
V2 2 and_output DC 0

************************
* end of SPICE netlist *
************************
